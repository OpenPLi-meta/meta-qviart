SRCDATE = "20230831"

require qviart-libs.inc

SRC_URI[md5sum] = "3eae00f4428d01890deddd2d671db69a"
SRC_URI[sha256sum] = "ebe560fbc08d061b393c25f59a96ef3328e8cadaa23e33747e85b85b738b3808"
