KV = "4.4.35"
SRCDATE = "20230831"

require qviart-dvb-modules-hisi.inc

SRC_URI[md5sum] = "97c7e7776e3a494ea3b4491b85347f27"
SRC_URI[sha256sum] = "4a1a1ba0306707da50de38bc4d232907448016bb20587a1b76f50ee162a74c14"
